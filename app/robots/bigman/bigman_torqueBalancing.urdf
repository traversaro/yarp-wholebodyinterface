Commit message: modified feet frames

File: app/robots/bigman/bigman_torqueBalancing.urdf (robot description, URDF)
Before this commit: robot bigman, 85 links, 84 joints
Links:
- link l_sole: mass None -> 0
- link r_sole: mass None -> 0
